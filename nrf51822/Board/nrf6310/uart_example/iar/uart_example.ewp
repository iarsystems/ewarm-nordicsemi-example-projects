# IAR project uart_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51822_xxAA NordicSemi nRF51822_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; NRF51; BOARD_NRF6310
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uart_example_iar.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: nrf51822_xxaa NordicSemi nrf51822_xxaa
  ICCARM.CCDefines: NDEBUG; NRF51; BOARD_NRF6310
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../Source/templates/iar/: iar_startup_nrf51.s
    ../: main.c
    ../../../../Source/simple_uart/: simple_uart.c
    ../../../../Source/templates/: system_nRF51.c
