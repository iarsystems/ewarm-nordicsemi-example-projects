# IAR project twi_sw_master_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51422_xxAA NordicSemi nRF51422_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; NRF51
  ICCARM.CCIncludePath2: ..\..\..\..\Include; ..\..\..\..\Include\ext_sensors; ..\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: twi_sw_master_example_iar.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: nrf51422_xxaa NordicSemi nrf51422_xxaa
  ICCARM.CCDefines: NDEBUG; NRF51
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../Source/ext_sensors/ds1624/: ds1624.c
    ../../../../Source/templates/iar/: iar_startup_nrf51.s
    ../: main.c
    ../../../../Source/ext_sensors/synaptics_touchpad/: synaptics_touchpad.c
    ../../../../Source/templates/: system_nrf51.c
    ../../../../Source/twi_master/: twi_sw_master.c
