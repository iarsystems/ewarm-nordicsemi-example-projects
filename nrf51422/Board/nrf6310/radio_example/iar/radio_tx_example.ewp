# IAR project radio_tx_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf51422_xxaa NordicSemi nrf51422_xxaa
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; NRF51
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: radio_tx_example_iar.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NRF51
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../Source/templates/iar/: iar_startup_nrf51.s
    ../: main_tx.c radio_config.c
    ../../../../Source/nrf_delay/: nrf_delay.c
    ../../../../Source/templates/: system_nrf51.c
