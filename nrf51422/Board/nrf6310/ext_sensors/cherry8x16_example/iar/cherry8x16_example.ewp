# IAR project cherry8x16_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51422_xxAA NordicSemi nRF51422_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; NRF51
  ICCARM.CCIncludePath2: ..\..\..\..\..\Include; ..\..\..\..\..\Include\ext_sensors
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cherry8x16_example_iar.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: nrf51422_xxaa NordicSemi nrf51422_xxaa
  ICCARM.CCDefines: NDEBUG; NRF51
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../Source/ext_sensors/cherry8x16/: cherry8x16.c
    ../../../../../Source/templates/iar/: iar_startup_nrf51.s
    ../: main.c
    ../../../../../Source/nrf_delay/: nrf_delay.c
    ../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../Source/templates/: system_nrf51.c
